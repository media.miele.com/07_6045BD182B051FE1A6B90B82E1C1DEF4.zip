Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 6d92eb22-ef7a-499d-a0b2-2d25a20252ce, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-14T23:53:52+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11502570_USA_K2602SF:36260211_USA_11502570_K2602SF, (2)
In: Default
Type - Material: z_Miele_Design_GRGR, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Zinc_Steel, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 603 mm; Height: 2125 mm; Depth: 608 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36260211_USA_11502570_K2602SF; sets with these values: 2

# IfcDistributionPort, Port_358389_1
Description: Flow; FlowDirection: SOURCEANDSINK
